# Keil uVision project MDAC.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MDAC +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c include: .\enc28j60;.\uip;.\uIP_arch;..\STM32_firmware;.\uip
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./Source/: main.c timer.c net_interface.c hardware_init.c hardware_init.h I2C.c I2C.h MDAC_conf.h web_content.c web_content.h string_functions.c string_functions.h scpi.c scpi.h net_interface.h
  group enc28j60
    ./enc28j60/: enc28j60.c
  group uIP
    ./uip/: uip.c uip_arp.c uiplib.c uipopt.h
  group MAX582x
    ./MAX582x/: MAX582x.h MAX582x.c dac_functions.c dac_functions.h
  group Flash
    ./flash/: flash.c flash.h
  group CRC
    ./CRC/: crc.c
    ./crc/: crc.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
